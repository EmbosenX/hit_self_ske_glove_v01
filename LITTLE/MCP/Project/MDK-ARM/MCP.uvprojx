# Keil uVision project MCP.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F032x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.19
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) IROM2(0x1FFF0F80,0x00000020) XROM(0x1FFF0E00,0x00000080) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MCP_LITTLE +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F032x8
  c include: ..\..\User\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\PY32F032\Include;..\..\Drivers\PY32F032_HAL_Driver\Inc;..\..\Drivers\FreeRTOS\Source\include;..\..\Drivers\FreeRTOS\Source\portable\MemMang;..\..\Drivers\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\..\Drivers\FreeRTOS\Source\CMSIS_RTOS;..\..\Drivers\FreeRTOS;..\..\Drivers\BSP
  library: MicroLIB
  memory RVCT1: ROM 0x1fff0e00 size 0x80
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x1fff0f80 size 0x20
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ./: startup_py32f032xx.s
  group Application/User
    ../../User/Src/: main.c py32f032_hal_msp.c py32f032_it.c system_py32f032.c app_usart_task.c app_sample_task.c app_tac_config.c
  group BSP
    ../../Drivers/BSP/: usart.c uart.c adc.c adc_sample.c gpio.c
  group Drivers/PY32F032_HAL_Driver
    ../../Drivers/PY32F032_HAL_Driver/Src/: py32f032_hal.c py32f032_hal_adc.c py32f032_hal_adc_ex.c py32f032_hal_comp.c py32f032_hal_cortex.c py32f032_hal_crc.c py32f032_hal_dma.c py32f032_hal_flash.c py32f032_hal_flash_ex.c py32f032_hal_gpio.c py32f032_hal_i2c.c py32f032_hal_i2c_ex.c py32f032_hal_i2s.c py32f032_hal_iwdg.c py32f032_hal_lptim.c py32f032_hal_lpuart.c py32f032_hal_lpuart_ex.c py32f032_hal_opa.c py32f032_hal_pwr.c py32f032_hal_pwr_ex.c py32f032_hal_rcc.c py32f032_hal_rcc_ex.c py32f032_hal_rtc.c py32f032_hal_rtc_ex.c py32f032_hal_sci.c py32f032_hal_sci_ex.c py32f032_hal_spi.c py32f032_hal_tim.c py32f032_hal_tim_ex.c py32f032_hal_uart.c py32f032_hal_usart.c py32f032_hal_wwdg.c
  group FreeRTOS
    ../../Drivers/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Drivers/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../Drivers/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.6.0
